# Keil uVision project RobotControl.uvproj, settings and files
target RobotControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RobotControl +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\User\Adc;..\User\AnalogIic;..\User\Beep;..\User\Blutooth;..\User\Error;..\User\Mpu6050;..\User\Mpu6050\eMPL;..\User\Oled;..\User\RgbLed;..\User\Robot;..\User\Servo;..\User\Speech;..\User\Usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/Servo/: Servo.c
    ../USER/Oled/: Oled.c
    ../USER/Blutooth/: Bluetooth.c
    ../USER/RgbLed/: RgbLed.c
    ../USER/Mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../USER/Mpu6050/: Mpu6050.c
    ../USER/AnalogIic/: AnalogIic.c
    ../USER/Beep/: Beep.c
    ../USER/Usart/: Usart.c
    ../USER/Adc/: Adc.c
    ../USER/Robot/: RobotControl.c
    ../USER/Speech/: Speech.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group Common
    ../Common/: common.c
